# Autodesk Inventor part: Drawing21
## iProperties
Created: 2007-10
Part Number: Drawing21
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
